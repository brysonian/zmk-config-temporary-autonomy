## boards/shields/temporary_autonomy/Kconfig.defconfig
```kconfig
if SHIELD_TAZ

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
  default "TAZ"

endif
```
